# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52810_xxAA NordicSemi nRF52810_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52810_XXAA; NRF52_PAN_74; NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3; NRF_DFU_SETTINGS_VERSION=2; NRF_DFU_SVCI_ENABLED; NRF_SD_BLE_API_VERSION=7; S112; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1; __WCHAR_T_SIZE=32; BUZ; WLI
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: D:\nordic2\DeviceDownload (2)\BOOTLOADER\secure_bootloader\pca10040e_s112_ble\config; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\oberon; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\boards; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\softdevice\s112\headers\nrf52; D:\nordic2\DeviceDownload (2)\BOOTLOADER\modules\nrfx\hal; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\atomic; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\atomic_fifo; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\balloc; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\bootloader; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\bootloader\ble_dfu; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\bootloader\dfu; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crc32; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\cc310; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\cc310_bl; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\cifra; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\mbedtls; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\micro_ecc; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\nrf_hw; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\nrf_sw; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\oberon; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\crypto\backend\optiga; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\delay; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\experimental_section_vars; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\fstorage; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\log\src; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\mem_manager; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\memobj; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\queue; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\ringbuf; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\ringbuf; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\scheduler; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\sha256; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\stack_info; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\strerror; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\svc; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\util; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\softdevice\common; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\softdevice\s112\headers; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\toolchain\cmsis\include; D:\nordic2\DeviceDownload (2)\BOOTLOADER\external\micro-ecc\micro-ecc; D:\nordic2\DeviceDownload (2)\BOOTLOADER\external\nano-pb; D:\nordic2\DeviceDownload (2)\BOOTLOADER\external\nrf_oberon; D:\nordic2\DeviceDownload (2)\BOOTLOADER\external\nrf_oberon\include; D:\nordic2\DeviceDownload (2)\BOOTLOADER\integration\nrfx; D:\nordic2\DeviceDownload (2)\BOOTLOADER\modules\nrfx\hal; D:\nordic2\DeviceDownload (2)\BOOTLOADER\modules\nrfx\mdk; D:\nordic2\DeviceDownload (2)\BOOTLOADER\modules\nrfx; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\libraries\log; D:\nordic2\DeviceDownload (2)\BOOTLOADER\secure_bootloader; D:\nordic2\DeviceDownload (2)\BOOTLOADER\components\ble\common; D:\nordic2\DeviceDownload (2)\BOOTLOADER\config\nrf52810
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52810_XXAA; NRF52_PAN_74; NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3; NRF_DFU_SETTINGS_VERSION=2; NRF_DFU_SVCI_ENABLED; NRF_SD_BLE_API_VERSION=7; S112; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  OBJCOPY.OOCOutputFile: bootloader.hex
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: D:\nordic2\DeviceDownload (2)\BOOTLOADER\secure_bootloader\pca10040e_s112_ble\iar\secure_bootloader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application
    ./: dfu_public_key.c
    secure_bootloader/: main.c
    secure_bootloader/pca10040e_s112_ble/config/: sdk_config.h
  group Board Definition
    components/boards/: boards.c
  group nano_pb
    external/nano-pb/: pb_common.c pb_decode.c
  group None
    modules/nrfx/mdk/: iar_startup_nrf52810.s system_nrf52810.c
  group nRF_BLE
    components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend nRF sw
    components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend Oberon
    components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend uECC
    components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    modules/nrfx/hal/: nrf_nvmc.c
    modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    components/libraries/scheduler/: app_scheduler.c
    components/libraries/crc32/: crc32.c
    components/libraries/mem_manager/: mem_manager.c
    components/libraries/atomic_fifo/: nrf_atfifo.c
    components/libraries/atomic/: nrf_atomic.c
    components/libraries/balloc/: nrf_balloc.c
    components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    components/libraries/queue/: nrf_queue.c
    components/libraries/ringbuf/: nrf_ringbuf.c
    components/libraries/experimental_section_vars/: nrf_section_iter.c
    components/libraries/strerror/: nrf_strerror.c
    components/libraries/sha256/: sha256.c
  group nRF_Oberon_Crypto
    external/nrf_oberon/lib/cortex-m4/soft-float/short-wchar/: liboberon_3.0.8.a
  group nRF_micro-ecc
    external/micro-ecc/nrf52nf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_SoftDevice
    components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_SVC
    components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    components/libraries/svc/: nrf_svc_handler.c
